DTB_SUBDIR="dts/"

require recipes-kernel/linux/enclustra-linux-altera-latest.inc

